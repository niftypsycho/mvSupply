File: HARDWARE/uSupply/uSupply/uSupply.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Added gitignore
same as before
Parts:
- G1: renamed from G?; value (none) -> G
